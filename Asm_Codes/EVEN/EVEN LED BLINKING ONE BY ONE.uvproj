# Keil uVision project EVEN LED BLINKING ONE BY ONE.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052D Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x0000-0x1FFF) CLOCK(40000000)
  output: EVEN LED BLINKING ONE BY ONE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 EVEN PINS LED BLYNKING.asm
