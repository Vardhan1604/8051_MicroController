# Keil uVision project CHANGE TH 0 POSITION.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052D Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x0000-0x1FFF) CLOCK(40000000)
  output: CHANGE TH 0 POSITION +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CHANGE 0 POSITION.asm
