# Keil uVision project KEYPAD_LCD_PassWord_Check.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052D Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x0000-0x1FFF) CLOCK(40000000)
  output: KEYPAD_LCD_PassWord_Check +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Main_Handler.c Delay.c KEYPAD.c LCD.c Ports.h
