# Keil uVision project LCD_CGRAM_8_characters.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052D Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x0000-0x1FFF) CLOCK(40000000)
  output: LCD_CGRAM_8_characters +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD_CGRAM_8_characters.c Delay.c LCD.c CGRAM_SP.c
